# Keil uVision project main_boardbootloader.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: bootloader +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\STM32F10x_FWLib\inc;..\HARDWARE\stmflash;..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\SYSTEM\usart;..\HARDWARE\IAR
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group lib
    ../STM32F10x_FWLib/src/: stm32f10x_flash.c misc.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c
  group user
    ./: system_stm32f10x.c main.c
  group core
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group system
    ../SYSTEM/usart/: usart.c
  group hardware
    ../HARDWARE/stmflash/: stm_flash.c
    ../HARDWARE/IAR/: iar.c
